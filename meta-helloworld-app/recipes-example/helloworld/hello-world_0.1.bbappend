do_compile:append() {
	echo "compile......."
}
