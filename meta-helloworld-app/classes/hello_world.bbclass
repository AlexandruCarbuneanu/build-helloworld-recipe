addtask hello
helloCls_do_hello () {
	echo "running helloCls_do_hello"
}

EXPORT_FUNCTIONS do_hello
